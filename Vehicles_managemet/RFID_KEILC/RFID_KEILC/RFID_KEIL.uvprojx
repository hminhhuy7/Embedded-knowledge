# Keil uVision project RFID_KEIL.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RFID_KEIL
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER,HSE_VALUE = 8000000
  c include: .\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\CMSIS\Include;.\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\inc;.\src;.\TM;.\fatfs;.\fatfs\drivers;.\fatfs\option
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group inc
    ./inc/: main.h RFID_rc522.h spi.h stm32f4xx_conf.h usart.h tim.h tm_stm32f4_fatfs.h
  group src
    ./src/: main.c system_stm32f4xx.c RFID_rc522.c spi.c usart.c tim.c
  group stdlib
    ./STM32F4xx_DSP_StdPeriph_Lib_V1.9.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c stm32f4xx_dma.c stm32f4xx_sdio.c
  group startup
    ./STM32F4xx_DSP_StdPeriph_Lib_V1.9.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group TIM
    ./TM/: defines.h tm_stm32f4_delay.c tm_stm32f4_delay.h tm_stm32f4_fatfs.c tm_stm32f4_fatfs.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h tm_stm32f4_spi.c tm_stm32f4_spi.h
  group FAT
    ./fatfs/option/: syscall.c unicode.c
    ./fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ./fatfs/drivers/: fatfs_sd_sdio.c fatfs_sd_sdio.h
